<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>variable_slider_0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2100000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>variable_slider_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1e9</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>variable_0</value></param>
<param><key>max</key><value>10000500e2</value></param>
<param><key>min</key><value>9999000e2</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>type</key><value>float</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/media/ubuntu/Data/Users/Student/multipfbrec</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>samples_per_symbol</key><value>12</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>2</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_channelizer_ccf</key>
<param><key>id</key><value>pfb_channelizer_ccf_0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>bus_conns</key><value>[[0,1,2],]</value></param>
<param><key>ch_map</key><value>[]</value></param>
<param><key>nchans</key><value>6</value></param>
<param><key>osr</key><value>6</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1, 1, 0.05, 0.05, 80)</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>76.8</value></param>
<param><key>freq0</key><value>12345e5</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>2.1e6</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>blks2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_0_2</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>pfb_channelizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
